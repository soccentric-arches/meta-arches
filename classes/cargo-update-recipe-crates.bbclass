# cargo-update-recipe-crates — kirkstone backport of oe-core's class.
#
# oe-core only ships this class from scarthgap onward; meta-rust-bin does not
# provide it either. Arches-Configuration's meta-webconfig webconfigd.bb
# (kas layer set, this branch builds poky kirkstone) inherits it, so a recipe
# inheriting it failed to parse ("Could not inherit file
# classes/cargo-update-recipe-crates.bbclass") and the image build aborted at
# parse time. This file restores the class for this layer.
#
# Same behavior as upstream (MIT, oe-core meta/classes-recipe/cargo-update-
# recipe-crates.bbclass): `bitbake -c update_crates <recipe>` reads the
# Cargo.lock files under CARGO_LOCK_SRC_DIR and rewrites
# ${THISDIR}/${BPN}-crates.inc with crate://crates.io SRC_URI entries plus
# their sha256 checksums. It is maintainer tooling only — do_update_crates is
# not in the do_build dependency chain, so image builds never run it.
#
# Kirkstone adaptation: the task's python runs under python3-native (3.10),
# which has no tomllib (3.11+). Falls back to a minimal Cargo.lock parser.

addtask do_update_crates after do_patch
do_update_crates[depends] = "python3-native:do_populate_sysroot"
do_update_crates[nostamp] = "1"
do_update_crates[doc] = "Update the recipe by reading Cargo.lock and write in ${THISDIR}/${BPN}-crates.inc"

# The directory where to search for Cargo.lock files
CARGO_LOCK_SRC_DIR ??= "${S}"

do_update_crates() {
    TARGET_FILE="${THISDIR}/${BPN}-crates.inc"

    nativepython3 - <<EOF
def get_crates(f):
    c_list = '# from %s' % os.path.relpath(f, '${CARGO_LOCK_SRC_DIR}')
    c_list += '\nSRC_URI += " \\\'
    try:
        import tomllib
        crates = tomllib.load(open(f, 'rb'))
    except ImportError:
        # python3-native on kirkstone is 3.10 — no tomllib. Parse the subset
        # of TOML a Cargo.lock uses: [[package]] blocks with quoted keys.
        crates = {'package': parse_lock(f)}

    # Build a list with crates info that have crates.io in the source
    crates_candidates = list(filter(lambda c: 'crates.io' in c.get('source', ''), crates['package']))

    if not crates_candidates:
        print("WARNING: Unable to find any candidate crates that use crates.io")
        return None

    # Update crates uri and their checksum, to avoid name clashing on the checksum
    # we need to rename crates with name and version to have a unique key
    cksum_list = ''
    for c in crates_candidates:
        rename = "%s-%s" % (c['name'], c['version'])
        c_list += '\n    crate://crates.io/%s/%s \\' % (c['name'], c['version'])
        if 'checksum' in c:
            cksum_list += '\nSRC_URI[%s.sha256sum] = "%s"' % (rename, c['checksum'])

    c_list += '\n"\n'
    c_list += cksum_list
    c_list += '\n'
    return c_list


def parse_lock(path):
    """Minimal Cargo.lock reader: returns [{'name','version','source','checksum'}]."""
    import re
    key_re = re.compile(r'^(name|version|source|checksum)\s*=\s*"(.*)"\s*$')
    pkgs = []
    cur = None
    with open(path, 'r', encoding='utf-8') as fh:
        for raw in fh:
            line = raw.rstrip('\n')
            s = line.strip()
            if s == '[[package]]':
                if cur is not None:
                    pkgs.append(cur)
                cur = {}
                continue
            if cur is None or not s or s.startswith('#'):
                continue
            # Indented lines belong to nested tables (e.g. [dependencies]);
            # top-level keys of a [[package]] block are never indented.
            if line[0] in (' ', '\t'):
                continue
            m = key_re.match(s)
            if m and m.group(1) not in cur:
                cur[m.group(1)] = m.group(2)
    if cur is not None:
        pkgs.append(cur)
    return pkgs


import os
crates = "# Autogenerated with 'bitbake -c update_crates ${PN}'\n\n"
found = False
for root, dirs, files in os.walk('${CARGO_LOCK_SRC_DIR}'):
    # ignore git and patches directories
    if root.startswith(os.path.join('${CARGO_LOCK_SRC_DIR}', '.pc')):
        continue
    if root.startswith(os.path.join('${CARGO_LOCK_SRC_DIR}', '.git')):
        continue
    for file in files:
        if file == 'Cargo.lock':
            found = True
            cargo_lock_path = os.path.join(root, file)
            c = get_crates(cargo_lock_path)
            if c is not None:
                crates += c
if not found:
    raise ValueError("Unable to find any Cargo.lock in ${CARGO_LOCK_SRC_DIR}")
open("${TARGET_FILE}", 'w').write(crates)
EOF

    bbnote "Successfully update crates inside '${TARGET_FILE}'"
}